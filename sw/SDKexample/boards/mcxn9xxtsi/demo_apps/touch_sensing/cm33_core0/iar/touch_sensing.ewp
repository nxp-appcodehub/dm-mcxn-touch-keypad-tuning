# IAR project touch_sensing.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN947_core0 NXP MCXN947_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MCXN947VDF_cm33_core0; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe188,Pe069
  ICCARM.CCIncludePath2: ../../../../../../middleware/touch/source/drivers/tsi; ../../../../../../middleware/touch/source/modules; ../../../../../../middleware/touch/include; ..; ../../../../../../middleware/touch/source/controls; ../../../../../../middleware/touch/source/electrodes; ../../../../../../middleware/touch/source/filters; ../../../../../../middleware/touch/source/keydetectors; ../../../../../../middleware/touch/source/system; ../../../../../../middleware/touch/source/safety; ../../../../../../middleware/touch/source/xtalk; ../../../../../../devices/MCXN947/drivers; ../../../../../../devices/MCXN947; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../CMSISm33/Core/Include; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../devices/MCXN947/utilities/debug_console; ../../../../../../../examples/tsi_mcxn9_app; ../../../../../../../examples/tsi_mcxn9_app/mcxn9xxevk; ../../../../../../../nt/source/controls; ../../../../../../../nt/source/electrodes; ../../../../../../../nt/source/filters; ../../../../../../../nt/source/keydetectors; ../../../../../../../nt/source/system; ../../../../../../../nt/source/safety; ../../../../../../../nt/source/xtalk; ../../../../../../../nt/source/drivers/tsi; ../../../../../../../nt/source/modules; ../../../../../../../nt/include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: touch_sensing.out
  ILINK.IlinkIcfFile: MCXN947_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXN947VDF_cm33_core0; SDK_DEBUGCONSOLE_UART; SERIAL_PORT_TYPE_UART=1; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ../../../../../../middleware/touch/source/drivers/tsi; ../../../../../../middleware/touch/source/modules; ../../../../../../middleware/touch/include; ..; ../../../../../../middleware/touch/source/controls; ../../../../../../middleware/touch/source/electrodes; ../../../../../../middleware/touch/source/filters; ../../../../../../middleware/touch/source/keydetectors; ../../../../../../middleware/touch/source/system; ../../../../../../middleware/touch/source/safety; ../../../../../../middleware/touch/source/xtalk; ../../../../../../devices/MCXN947/drivers; ../../../../../../devices/MCXN947; ../../../../../../components/uart; ../../../../../../components/serial_manager; ../../../../../../components/lists; ../../../../../../middleware/freemaster/src/common; ../../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial; ../../../../../../CMSIS/Core/Include; ../../../../../../devices/MCXN947/utilities/str; ../../../../../../devices/MCXN947/utilities/debug_console
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  group board
    ../../../../../../../examples/tsi_mcxn9_app/mcxn9xxevk/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../../devices/MCXN947/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/MCXN947/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_crc.c fsl_crc.h fsl_ctimer.c fsl_ctimer.h fsl_gpio.c fsl_gpio.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_tsi_v6.c fsl_tsi_v6.h
  group freemaster
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_can.c freemaster_can.h freemaster_defcfg.h freemaster_net.c freemaster_net.h freemaster_pdbdm.c freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_serial.h freemaster_sha.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h
  group freemaster/drivers
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mcan.c freemaster_mcan.h freemaster_mscan.c freemaster_mscan.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/platforms
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group source
    ../../../../../../../examples/tsi_mcxn9_app/: freemaster_cfg.h main.c main.h nt_setup.c nt_setup.h tsi_trace.c tsi_trace.h
  group startup
    ../../../../../../devices/MCXN947/iar/: startup_MCXN947_cm33_core0.s
  group touch/include
    ../../../../../../../nt/include/: nt.h nt_control_arotary.h nt_control_aslider.h nt_control_keypad.h nt_control_matrix.h nt_control_proxi.h nt_control_rotary.h nt_control_slider.h nt_controls.h nt_electrodes.h nt_filters.h nt_gpio.h nt_keydetector_afid.h nt_keydetector_mbw.h nt_keydetector_safa.h nt_keydetector_usafa.h nt_keydetectors.h nt_module_cs.h nt_module_gpio.h nt_module_gpioint.h nt_module_tsi.h nt_module_tsi_rat_alpha.h nt_modules.h nt_safety.h nt_system.h nt_types.h nt_xtalk.h
  group touch/source
    ../../../../../../../nt/source/: nt.c
    ../../../../../../../nt/source/controls/: nt_control_arotary.c nt_control_arotary_prv.h nt_control_aslider.c nt_control_aslider_prv.h nt_control_keypad.c nt_control_keypad_prv.h nt_control_matrix.c nt_control_matrix_prv.h nt_control_proxi.c nt_control_proxi_prv.h nt_control_rotary.c nt_control_rotary_prv.h nt_control_slider.c nt_control_slider_prv.h nt_controls.c nt_controls_prv.h
    ../../../../../../../nt/source/drivers/tsi/: nt_drv_tsi_common.c nt_drv_tsi_driver.c nt_drv_tsi_driver.h nt_drv_tsi_v6_driver_specific.c nt_drv_tsi_v6_driver_specific.h
    ../../../../../../../nt/source/electrodes/: nt_electrodes.c nt_electrodes_prv.h
    ../../../../../../../nt/source/filters/: nt_filters.c nt_filters_prv.h
    ../../../../../../../nt/source/keydetectors/: nt_keydetector_afid.c nt_keydetector_afid_prv.h nt_keydetector_mbw.c nt_keydetector_mbw_prv.h nt_keydetector_prv.h nt_keydetector_safa.c nt_keydetector_safa_prv.h nt_keydetector_usafa.c nt_keydetector_usafa_prv.h
    ../../../../../../../nt/source/modules/: nt_module_gpio.c nt_module_gpio_prv.h nt_module_gpioint.c nt_module_gpioint_prv.h nt_module_tsi.c nt_module_tsi_prv.h nt_modules.c nt_modules_prv.h
    ../../../../../../../nt/source/safety/: nt_safety.c nt_safety_crc.c nt_safety_crc.h nt_safety_gpio.c nt_safety_gpio.h nt_safety_prv.h
    ../../../../../../../nt/source/system/: nt_system.c nt_system_frmstr.c nt_system_frmstr_prv.h nt_system_mem.c nt_system_mem_prv.h nt_system_prv.h
    ../../../../../../../nt/source/xtalk/: nt_xtalk.c nt_xtalk_prv.h
  group utilities
    ../../../../../../devices/MCXN947/utilities/: fsl_assert.c
    ../../../../../../devices/MCXN947/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../../devices/MCXN947/utilities/str/: fsl_str.c fsl_str.h
